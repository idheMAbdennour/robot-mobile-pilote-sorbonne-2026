# Keil uVision project Robot.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: robot
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./src/: adc.c adc.h buttons.c buttons.h capteur_inductif.c capteur_inductif.h decode_enveloppe.c decode_enveloppe.h dtmf.c dtmf.h emission_ir.c emission_ir.h interruptions.c interruptions.h led_register.c led_register.h main.c moteur.c moteur.h proximetre.c proximetre.h pwm.c pwm.h recep_spi.c recep_spi.h robot_state.c robot_state.h status.c status.h timers.c timers.h uart.c uart.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
