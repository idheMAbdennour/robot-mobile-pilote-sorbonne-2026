# Keil uVision project centrale.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./Centrale/: main.c
    ./Centrale/InterfacePoste/: SendMessagePoste.c SendMessagePoste.h InterfacePostecentraleConfig.c InterfacePostecentraleConfig.h ReceiveMessagePoste.c ReceiveMessagePoste.h
    ./Centrale/Config/: Config_numeroPoste.c Config_numeroPoste.h
    ./Centrale/ReceptionIR/: RecepteurIR_Centrale.c RecepteurIR_Centrale.h
    ./Centrale/EmetteurDTMF/: EmetteurDTMF.c GestionAiguillage.c GestionAiguillage.h EmetteurDTMF.h
    ./Centrale/InterfaceCentraleSupervision/: InterfaceCentraleSupervision.c InterfaceCentraleSupervision.h
    ./Centrale/GenerateurFil/: fil.c fil.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
